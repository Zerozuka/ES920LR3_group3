/*******************************************************************************
* phy_protocol file.
*
* (c) Copyright 2021, EASEL, Inc.  All rights reserved.
*
* No part of this document may be reproduced in any form - including copied,
* transcribed, printed or by any electronic means - without specific written
* permission from EASEL.
*
*******************************************************************************/

#include "usr_common.h"

#if defined(BLD_USE_FSK_R)
#include "stack/phy/protocol/phy_protocol.h"

/*******************************************************************************
********************************************************************************
* Private macros
********************************************************************************
*******************************************************************************/
#define PhyFrame_getFooter_FSK(frame, sduSize)  ( (phyFooter_FSK_t*)( (uint8_t*)(&frame->sdu) + (sduSize) ) )

#define PhyDataModeSwitch_DISABLE   0
#define PhyFcsType_CRC_2OCTET       1
#define PhyDataWhitening_ENABLE     1

#define PhyFrameLengthField_FSK(sduSize)                    ( (sduSize) + sizeof(phyFooter_FSK_t) )
#define PhyFrameLengthFieldMax_FSK                          ( PhyFrameLengthField(PhySduSizeMax_FSK) )
#define PhyFrameLengthField_calcSduSize_FSK(frameLength)    ( (frameLength) - sizeof(phyFooter_FSK_t) )

/*******************************************************************************
********************************************************************************
* Private function declarations
********************************************************************************
*******************************************************************************/
static uint16_t PhyFrame_calcFcs_FSK( const uint8_t* base, uint8_t length );
static void     PhyFrame_bitSwap_FSK( uint8_t* base, uint8_t length );
//static void   PhyFrame_whitening_FSK( uint8_t* base, uint8_t length );
static void     PhyFrame_bitSwapAndWhitening_FSK( uint8_t* base, uint8_t length );
static void     PhyFrame_whiteningAndBitSwap_FSK( uint8_t* base, uint8_t length );

/*******************************************************************************
********************************************************************************
* Private memory declarations
********************************************************************************
*******************************************************************************/

static const uint8_t whiteningLookUpTable[0x100] =
    {
        0xF0, 0x0E, 0xCD, 0xF6, 0xC2, 0x19, 0x12, 0x75,
        0x3D, 0xE9, 0x1C, 0xB8, 0xCB, 0x2B, 0x05, 0xAA,
        0xBE, 0x16, 0xEC, 0xB6, 0x06, 0xDD, 0xC7, 0xB3,
        0xAC, 0x63, 0xD1, 0x5F, 0x1A, 0x65, 0x0C, 0x98,
        0xA9, 0xC9, 0x6F, 0x49, 0xF6, 0xD3, 0x0A, 0x45,
        0x6E, 0x7A, 0xC3, 0x2A, 0x27, 0x8C, 0x10, 0x20,
        0x62, 0xE2, 0x6A, 0xE3, 0x48, 0xC5, 0xE6, 0xF3,
        0x68, 0xA7, 0x04, 0x99, 0x8B, 0xEF, 0xC1, 0x7F,
        0x78, 0x87, 0x66, 0x7B, 0xE1, 0x0C, 0x89, 0xBA,
        0x9E, 0x74, 0x0E, 0xDC, 0xE5, 0x95, 0x02, 0x55,
        0x5F, 0x0B, 0x76, 0x5B, 0x83, 0xEE, 0xE3, 0x59,
        0xD6, 0xB1, 0xE8, 0x2F, 0x8D, 0x32, 0x06, 0xCC,
        0xD4, 0xE4, 0xB7, 0x24, 0xFB, 0x69, 0x85, 0x22,
        0x37, 0xBD, 0x61, 0x95, 0x13, 0x46, 0x08, 0x10,
        0x31, 0x71, 0xB5, 0x71, 0xA4, 0x62, 0xF3, 0x79,
        0xB4, 0x53, 0x82, 0xCC, 0xC5, 0xF7, 0xE0, 0x3F,
        0xBC, 0x43, 0xB3, 0xBD, 0x70, 0x86, 0x44, 0x5D,
        0x4F, 0x3A, 0x07, 0xEE, 0xF2, 0x4A, 0x81, 0xAA,
        0xAF, 0x05, 0xBB, 0xAD, 0x41, 0xF7, 0xF1, 0x2C,
        0xEB, 0x58, 0xF4, 0x97, 0x46, 0x19, 0x03, 0x66,
        0x6A, 0xF2, 0x5B, 0x92, 0xFD, 0xB4, 0x42, 0x91,
        0x9B, 0xDE, 0xB0, 0xCA, 0x09, 0x23, 0x04, 0x88,
        0x98, 0xB8, 0xDA, 0x38, 0x52, 0xB1, 0xF9, 0x3C,
        0xDA, 0x29, 0x41, 0xE6, 0xE2, 0x7B, 0xF0, 0x1F,
        0xDE, 0xA1, 0xD9, 0x5E, 0x38, 0x43, 0xA2, 0xAE,
        0x27, 0x9D, 0x03, 0x77, 0x79, 0xA5, 0x40, 0xD5,
        0xD7, 0x82, 0xDD, 0xD6, 0xA0, 0xFB, 0x78, 0x96,
        0x75, 0x2C, 0xFA, 0x4B, 0xA3, 0x8C, 0x01, 0x33,
        0x35, 0xF9, 0x2D, 0xC9, 0x7E, 0x5A, 0xA1, 0xC8,
        0x4D, 0x6F, 0x58, 0xE5, 0x84, 0x11, 0x02, 0x44,
        0x4C, 0x5C, 0x6D, 0x1C, 0xA9, 0xD8, 0x7C, 0x1E,
        0xED, 0x94, 0x20, 0x73, 0xF1, 0x3D, 0xF8, 0x0F,
    };

static const uint8_t swapBitTable[0x100] =
    {
        0x00, 0x80, 0x40, 0xC0, 0x20, 0xA0, 0x60, 0xE0,
        0x10, 0x90, 0x50, 0xD0, 0x30, 0xB0, 0x70, 0xF0,
        0x08, 0x88, 0x48, 0xC8, 0x28, 0xA8, 0x68, 0xE8,
        0x18, 0x98, 0x58, 0xD8, 0x38, 0xB8, 0x78, 0xF8,
        0x04, 0x84, 0x44, 0xC4, 0x24, 0xA4, 0x64, 0xE4,
        0x14, 0x94, 0x54, 0xD4, 0x34, 0xB4, 0x74, 0xF4,
        0x0C, 0x8C, 0x4C, 0xCC, 0x2C, 0xAC, 0x6C, 0xEC,
        0x1C, 0x9C, 0x5C, 0xDC, 0x3C, 0xBC, 0x7C, 0xFC,
        0x02, 0x82, 0x42, 0xC2, 0x22, 0xA2, 0x62, 0xE2,
        0x12, 0x92, 0x52, 0xD2, 0x32, 0xB2, 0x72, 0xF2,
        0x0A, 0x8A, 0x4A, 0xCA, 0x2A, 0xAA, 0x6A, 0xEA,
        0x1A, 0x9A, 0x5A, 0xDA, 0x3A, 0xBA, 0x7A, 0xFA,
        0x06, 0x86, 0x46, 0xC6, 0x26, 0xA6, 0x66, 0xE6,
        0x16, 0x96, 0x56, 0xD6, 0x36, 0xB6, 0x76, 0xF6,
        0x0E, 0x8E, 0x4E, 0xCE, 0x2E, 0xAE, 0x6E, 0xEE,
        0x1E, 0x9E, 0x5E, 0xDE, 0x3E, 0xBE, 0x7E, 0xFE,
        0x01, 0x81, 0x41, 0xC1, 0x21, 0xA1, 0x61, 0xE1,
        0x11, 0x91, 0x51, 0xD1, 0x31, 0xB1, 0x71, 0xF1,
        0x09, 0x89, 0x49, 0xC9, 0x29, 0xA9, 0x69, 0xE9,
        0x19, 0x99, 0x59, 0xD9, 0x39, 0xB9, 0x79, 0xF9,
        0x05, 0x85, 0x45, 0xC5, 0x25, 0xA5, 0x65, 0xE5,
        0x15, 0x95, 0x55, 0xD5, 0x35, 0xB5, 0x75, 0xF5,
        0x0D, 0x8D, 0x4D, 0xCD, 0x2D, 0xAD, 0x6D, 0xED,
        0x1D, 0x9D, 0x5D, 0xDD, 0x3D, 0xBD, 0x7D, 0xFD,
        0x03, 0x83, 0x43, 0xC3, 0x23, 0xA3, 0x63, 0xE3,
        0x13, 0x93, 0x53, 0xD3, 0x33, 0xB3, 0x73, 0xF3,
        0x0B, 0x8B, 0x4B, 0xCB, 0x2B, 0xAB, 0x6B, 0xEB,
        0x1B, 0x9B, 0x5B, 0xDB, 0x3B, 0xBB, 0x7B, 0xFB,
        0x07, 0x87, 0x47, 0xC7, 0x27, 0xA7, 0x67, 0xE7,
        0x17, 0x97, 0x57, 0xD7, 0x37, 0xB7, 0x77, 0xF7,
        0x0F, 0x8F, 0x4F, 0xCF, 0x2F, 0xAF, 0x6F, 0xEF,
        0x1F, 0x9F, 0x5F, 0xDF, 0x3F, 0xBF, 0x7F, 0xFF,
    };

static const uint16_t crc16Table[0x100] =
    {
        0x0000, 0x1189, 0x2312, 0x329B, 0x4624, 0x57AD, 0x6536, 0x74BF,
        0x8C48, 0x9DC1, 0xAF5A, 0xBED3, 0xCA6C, 0xDBE5, 0xE97E, 0xF8F7,
        0x1081, 0x0108, 0x3393, 0x221A, 0x56A5, 0x472C, 0x75B7, 0x643E,
        0x9CC9, 0x8D40, 0xBFDB, 0xAE52, 0xDAED, 0xCB64, 0xF9FF, 0xE876,
        0x2102, 0x308B, 0x0210, 0x1399, 0x6726, 0x76AF, 0x4434, 0x55BD,
        0xAD4A, 0xBCC3, 0x8E58, 0x9FD1, 0xEB6E, 0xFAE7, 0xC87C, 0xD9F5,
        0x3183, 0x200A, 0x1291, 0x0318, 0x77A7, 0x662E, 0x54B5, 0x453C,
        0xBDCB, 0xAC42, 0x9ED9, 0x8F50, 0xFBEF, 0xEA66, 0xD8FD, 0xC974,
        0x4204, 0x538D, 0x6116, 0x709F, 0x0420, 0x15A9, 0x2732, 0x36BB,
        0xCE4C, 0xDFC5, 0xED5E, 0xFCD7, 0x8868, 0x99E1, 0xAB7A, 0xBAF3,
        0x5285, 0x430C, 0x7197, 0x601E, 0x14A1, 0x0528, 0x37B3, 0x263A,
        0xDECD, 0xCF44, 0xFDDF, 0xEC56, 0x98E9, 0x8960, 0xBBFB, 0xAA72,
        0x6306, 0x728F, 0x4014, 0x519D, 0x2522, 0x34AB, 0x0630, 0x17B9,
        0xEF4E, 0xFEC7, 0xCC5C, 0xDDD5, 0xA96A, 0xB8E3, 0x8A78, 0x9BF1,
        0x7387, 0x620E, 0x5095, 0x411C, 0x35A3, 0x242A, 0x16B1, 0x0738,
        0xFFCF, 0xEE46, 0xDCDD, 0xCD54, 0xB9EB, 0xA862, 0x9AF9, 0x8B70,
        0x8408, 0x9581, 0xA71A, 0xB693, 0xC22C, 0xD3A5, 0xE13E, 0xF0B7,
        0x0840, 0x19C9, 0x2B52, 0x3ADB, 0x4E64, 0x5FED, 0x6D76, 0x7CFF,
        0x9489, 0x8500, 0xB79B, 0xA612, 0xD2AD, 0xC324, 0xF1BF, 0xE036,
        0x18C1, 0x0948, 0x3BD3, 0x2A5A, 0x5EE5, 0x4F6C, 0x7DF7, 0x6C7E,
        0xA50A, 0xB483, 0x8618, 0x9791, 0xE32E, 0xF2A7, 0xC03C, 0xD1B5,
        0x2942, 0x38CB, 0x0A50, 0x1BD9, 0x6F66, 0x7EEF, 0x4C74, 0x5DFD,
        0xB58B, 0xA402, 0x9699, 0x8710, 0xF3AF, 0xE226, 0xD0BD, 0xC134,
        0x39C3, 0x284A, 0x1AD1, 0x0B58, 0x7FE7, 0x6E6E, 0x5CF5, 0x4D7C,
        0xC60C, 0xD785, 0xE51E, 0xF497, 0x8028, 0x91A1, 0xA33A, 0xB2B3,
        0x4A44, 0x5BCD, 0x6956, 0x78DF, 0x0C60, 0x1DE9, 0x2F72, 0x3EFB,
        0xD68D, 0xC704, 0xF59F, 0xE416, 0x90A9, 0x8120, 0xB3BB, 0xA232,
        0x5AC5, 0x4B4C, 0x79D7, 0x685E, 0x1CE1, 0x0D68, 0x3FF3, 0x2E7A,
        0xE70E, 0xF687, 0xC41C, 0xD595, 0xA12A, 0xB0A3, 0x8238, 0x93B1,
        0x6B46, 0x7ACF, 0x4854, 0x59DD, 0x2D62, 0x3CEB, 0x0E70, 0x1FF9,
        0xF78F, 0xE606, 0xD49D, 0xC514, 0xB1AB, 0xA022, 0x92B9, 0x8330,
        0x7BC7, 0x6A4E, 0x58D5, 0x495C, 0x3DE3, 0x2C6A, 0x1EF1, 0x0F78,
    };


/*******************************************************************************
********************************************************************************
* Public functions
********************************************************************************
*******************************************************************************/

void PhyFrame_makeFrame_FSK( phyFrame_FSK_t* frame, uint8_t sduSize )
{
    phyHeader_FSK_t*    header  = &frame->header;
    phyFooter_FSK_t*    footer  = PhyFrame_getFooter_FSK( frame, sduSize );

    // Calc fcs
    const uint16_t      fcs     = PhyFrame_calcFcs_FSK( frame->sdu.data, sduSize );

    // Fill header
    memset( header, 0, sizeof(*header) );
    header->modeSwitch      = PhyDataModeSwitch_DISABLE;
    header->fcsType         = PhyFcsType_CRC_2OCTET;
    header->dataWhitening   = PhyDataWhitening_ENABLE;
    header->frameLength     = PhyFrameLengthField_FSK(sduSize);
    PhyFrame_bitSwap_FSK( header->byteAccess, 1 );  // LSB first

    // Fill footer
    memset( footer, 0, sizeof(*footer) );
    octet2_set( &footer->fcs, fcs );

    // Whitening
    PhyFrame_whiteningAndBitSwap_FSK( frame->sdu.data, header->frameLength );
}

bool_t PhyFrame_analyzeFrame_FSK( phyFrame_FSK_t* frame, uint8_t recvSize, uint8_t* sduSize )
{
    *sduSize = 0;

    /* check receive size (header) */
    if( recvSize < sizeof(phyHeader_FSK_t) )
    {
        return FALSE;
    }

    /* get header */
    phyHeader_FSK_t* header = &frame->header;
    PhyFrame_bitSwap_FSK( header->byteAccess, 1 ); // LSB first

    /* calc length */
    *sduSize = PhyFrameLengthField_calcSduSize_FSK( header->frameLength );

    /* check receive size (SDU) */
    if( recvSize < *sduSize )
    {
        return FALSE;
    }

    /* check header */
    if( header->modeSwitch != PhyDataModeSwitch_DISABLE )
    {
        return FALSE;
    }

    // bit swap
    if( header->dataWhitening == PhyDataWhitening_ENABLE )
    {
        // and dewhitening
        PhyFrame_bitSwapAndWhitening_FSK( frame->sdu.data, header->frameLength ); // LSB first
    }
    else
    {
        // bit swap only
        PhyFrame_bitSwap_FSK( frame->sdu.data, header->frameLength ); // LSB first
    }

    /* get footer */
    const phyFooter_FSK_t*  footer  = PhyFrame_getFooter_FSK( frame, *sduSize );

    // calc fcs
    const uint16_t          fcs     = PhyFrame_calcFcs_FSK( frame->sdu.data, *sduSize );

    /* check footer */
    if( octet2_get(&footer->fcs) != fcs )
    {
        return FALSE;
    }

    return TRUE;
}

/*******************************************************************************
********************************************************************************
* Private functions
********************************************************************************
*******************************************************************************/

static uint16_t PhyFrame_calcFcs_FSK( const uint8_t* base, uint8_t length )
{
    WDG_Refresh();

    uint16_t crc = 0;

    /* calc crc */
    for( uint8_t idx = 0; idx < length; idx++ )
    {
        crc ^= base[idx];

#if 1
        crc = (crc >> 8) ^ crc16Table[crc & 0x00FF];
#else
        for( uint8_t i=0; i<8; i++ )
        {
            if( crc & 0x0001 )
            {
                crc >>= 1;
                crc ^= 0x8408;
            }
            else
            {
                crc >>= 1;
            }
        }
#endif
    }

    return crc;
}

static void PhyFrame_bitSwap_FSK( uint8_t* base, uint8_t length )
{
    WDG_Refresh();

    /* data whitening */
    for( uint8_t idx = 0; idx < length; idx++ )
    {
        base[idx] = swapBitTable[base[idx]];
    }
}

#if 0
static void PhyFrame_whitening_FSK( uint8_t* base, uint8_t length )
{
    WDG_Refresh();

    /* data whitening */
    for( uint8_t idx = 0; idx < length; idx++ )
    {
        base[idx] ^= whiteningLookUpTable[idx % sizeof(whiteningLookUpTable)];
    }
}
#endif

static void PhyFrame_bitSwapAndWhitening_FSK( uint8_t* base, uint8_t length )
{
    WDG_Refresh();

    /* data whitening */
    for( uint8_t idx = 0; idx < length; idx++ )
    {
        base[idx] = swapBitTable[base[idx]] ^ whiteningLookUpTable[idx % sizeof(whiteningLookUpTable)];
    }
}

static void PhyFrame_whiteningAndBitSwap_FSK( uint8_t* base, uint8_t length )
{
    WDG_Refresh();

    /* data whitening */
    for( uint8_t idx = 0; idx < length; idx++ )
    {
        base[idx] = swapBitTable[base[idx] ^ whiteningLookUpTable[idx % sizeof(whiteningLookUpTable)]];
    }
}

#endif
