# IAR project ES920LR3.ewp, settings and files
configuration ES920LR3 (ARM, debug)
  General.OGChipSelectEditMenu: STM32WLE5JC ST STM32WLE5JC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32WLE5xx; CORE_CM4
  ICCARM.CCIncludePath2: ../Inc; ../Drivers\STM32WLxx_HAL_Driver\Inc; ../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32WLxx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\\Inc
  OBJCOPY.OOCOutputFile: ES920LR3.hex
  ILINK.IlinkOutputFile: ES920LR3.out
  ILINK.IlinkIcfFile: stm32wle5xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wle5xx.s
  group Application/User
    ../Inc/: gpio.h lptim.h main.h rtc.h stm32wlxx_hal_conf.h stm32wlxx_it.h subghz.h usart.h usr_common.h wwdg.h
    ../Src/: main.c gpio.c lptim.c rtc.c subghz.c usart.c wwdg.c stm32wlxx_it.c stm32wlxx_hal_msp.c
  group Application/User/app
    ../Src/app/: commctl.c do_configuration.c do_operation.c params.c usr_main.c usr_util.c
    ../Inc/app/: commctl.h do_configuration.h do_operation.h memmap.h params.h usr_main.h usr_util.h
  group Application/User/config
    ../Inc/config/: usr_config.h
  group Application/User/middle/AES
    ../Src/middle/AES/: aes.c
    ../Inc/middle/AES/: aes.h
  group Application/User/platform
    ../Src/platform/: events.c led.c pendsv.c powerctl.c serial.c timerctl.c
    ../Inc/platform/: events.h led.h pendsv.h powerctl.h serial.h timerctl.h
  group Application/User/stack
    ../Src/stack/: smac.c
    ../Inc/stack/: smac.h smac_stack.h
  group Application/User/stack/mac
    ../Src/stack/mac/: smac_trans.c smac_user.c
    ../Inc/stack/mac/: smac_trans.h smac_user.h
  group Application/User/stack/mac/protocol
    ../Src/stack/mac/protocol/: smac_trans_protocol.c smac_trans_protocol_fsk.c smac_trans_protocol_lora.c smac_user_protocol_fsk_r.c smac_user_protocol_lora_r.c
    ../Inc/stack/mac/protocol/: smac_trans_protocol.h smac_trans_protocol_fsk.h smac_trans_protocol_lora.h smac_user_protocol.h smac_user_protocol_fsk.h smac_user_protocol_fsk_r.h smac_user_protocol_lora.h smac_user_protocol_lora_nr.h smac_user_protocol_lora_r.h
  group Application/User/stack/phy
    ../Src/stack/phy/: phy.c phy_arib.c phy_radio.c
    ../Inc/stack/phy/: phy.h phy_arib.h phy_radio.h
  group Application/User/stack/phy/protocol
    ../Inc/stack/phy/protocol/: phy_protocol.h phy_protocol_fsk.h phy_protocol_lora.h phy_radio_protocol.h
    ../Src/stack/phy/protocol/: phy_protocol_fsk.c
  group Application/User/stack/radio
    ../Src/stack/radio/: radio.c radio_bsp.c radio_driver.c
    ../Inc/stack/radio/: radio.h radio_bsp.h radio_driver.h
  group Drivers/CMSIS
    ../Drivers/CMSIS/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
    ../Drivers/CMSIS/Device/ST/STM32WLxx/Include/: stm32wle5xx.h stm32wlxx.h system_stm32wlxx.h
    ../Src/: system_stm32wlxx.c
  group Drivers/STM32WLxx_HAL_Driver
    ../Drivers/STM32WLxx_HAL_Driver/Inc/: stm32wlxx_hal.h stm32wlxx_hal_cortex.h stm32wlxx_hal_def.h stm32wlxx_hal_dma.h stm32wlxx_hal_dma_ex.h stm32wlxx_hal_exti.h stm32wlxx_hal_flash.h stm32wlxx_hal_flash_ex.h stm32wlxx_hal_gpio.h stm32wlxx_hal_gpio_ex.h stm32wlxx_hal_lptim.h stm32wlxx_hal_pwr.h stm32wlxx_hal_pwr_ex.h stm32wlxx_hal_rcc.h stm32wlxx_hal_rcc_ex.h stm32wlxx_hal_rtc.h stm32wlxx_hal_rtc_ex.h stm32wlxx_hal_subghz.h stm32wlxx_hal_tim.h stm32wlxx_hal_tim_ex.h stm32wlxx_hal_uart.h stm32wlxx_hal_uart_ex.h stm32wlxx_hal_wwdg.h stm32wlxx_ll_bus.h stm32wlxx_ll_dma.h stm32wlxx_ll_dmamux.h stm32wlxx_ll_exti.h stm32wlxx_ll_pwr.h stm32wlxx_ll_rcc.h stm32wlxx_ll_spi.h stm32wlxx_ll_system.h
    ../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal_lptim.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal.c stm32wlxx_hal_exti.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_subghz.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c stm32wlxx_hal_wwdg.c
